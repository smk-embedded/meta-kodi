FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
# no support for cfg at the moment, so we need to provide defconfig
#SRC_URI += "file://imx6-kodi.cfg"
