require kodi.inc

BRANCH = "Jarvis"
SRCREV="2baa51266144e970bdb04a959542298cd449d13f"
PV = "16+gitr${SRCPV}"
PR = "${INC_PR}"

